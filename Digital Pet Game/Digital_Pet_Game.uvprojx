# Keil uVision project Digital_Pet_Game.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_Interrupts
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group inc
    ./: GPIO.h SysTick_Delay.h EduBase_LCD.h Seven_Segment_Display.h PMOD_ENC.h Timer_0A_Interrupt.h Timer_1A_Interrupt.h Pets.h PWM_PF1.h Timer_0B_Interrupt.h
  group src
    ./: GPIO.c SysTick_Delay.c EduBase_LCD.c Seven_Segment_Display.c PMOD_ENC.c Timer_0A_Interrupt.c Timer_1A_Interrupt.c Pets.c PWM_PF1.c Timer_0B_Interrupt.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
